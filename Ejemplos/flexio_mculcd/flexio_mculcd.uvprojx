# Keil uVision project flexio_mculcd.uvprojx, settings and files
target flexio_mculcd debug (6180000::V6.18::ARMCLANG)
  device: MCXA156VLL NXP
  pack: NXP.MCXA156_DFP.25.12.00
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU)  DSP
  output: flexio_mculcd.out
  AfterMake: fromelf.exe --output "$Lflexio_mculcd_int_transfer.bin" --bincombined "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, BOARD_LCD_S035=1, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MCXA156VLL, MCXA156_SERIES
  c misc: -include source/mcux_config.h -include source/mcuxsdk_version.h -fno-common -fdata-sections -fno-builtin -mthumb
  c include: board;source;CMSIS;CMSIS/m-profile;component/uart;device;device/periph1;drivers;lcdc;utilities;utilities/debug_console_lite;utilities/str;video
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG,__CC_ARM,KEIL, MCUXPRESSO_SDK, CPU_MCXA156VLL, MCXA156_SERIES
  asm misc: -include ../mcux_config.h
  asm include: source;CMSIS;CMSIS/m-profile;component/uart;device;device/periph1;drivers;lcdc;utilities;utilities/debug_console_lite;utilities/str;video
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x2000
  memory RVCT5: ROM 0x13000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x1e000
  memory RVCT10: RAM 0x4000000 size 0x3000
  scatter file: MCXA156/mdk/MCXA156_flash.scf
  link misc: --remove --entry=Reset_Handler --info=sizes,totals,unused,veneers
--remove
  group board
    board/: app.h board.c board.h clock_config.c clock_config.h hardware_init.c
  group CMSIS
    CMSIS/: cmsis_armclang.h cmsis_compiler.h cmsis_version.h core_cm33.h tz_context.h
  group CMSIS/m-profile
    CMSIS/m-profile/: armv8m_mpu.h cmsis_armclang_m.h
  group component/uart
    component/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group device
    device/: fsl_device_registers.h MCXA156.h MCXA156_COMMON.h MCXA156_features.h system_MCXA156.c system_MCXA156.h
  group device/periph1
    device/periph1/: PERI_ADC.h PERI_AOI.h PERI_CAN.h PERI_CDOG.h PERI_CMC.h PERI_CRC.h PERI_CTIMER.h PERI_DEBUGMAILBOX.h PERI_DMA.h PERI_EIM.h PERI_EQDC.h PERI_ERM.h PERI_FLEXIO.h PERI_FMC.h PERI_FMU.h PERI_FMUTEST.h PERI_FREQME.h PERI_GLIKEY.h PERI_GPIO.h PERI_I3C.h PERI_INPUTMUX.h PERI_LPCMP.h PERI_LPDAC.h PERI_LPI2C.h PERI_LPSPI.h PERI_LPTMR.h PERI_LPUART.h PERI_MRCC.h PERI_OPAMP.h PERI_OSTIMER.h PERI_PORT.h PERI_PWM.h PERI_SCG.h PERI_SPC.h PERI_SYSCON.h PERI_TRDC.h PERI_USB.h PERI_UTICK.h PERI_VBAT.h PERI_WAKETIMER.h PERI_WUU.h PERI_WWDT.h
  group drivers
    drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_flexio.c fsl_flexio.h fsl_flexio_mculcd.c fsl_flexio_mculcd.h fsl_gpio.c fsl_gpio.h fsl_inputmux_connections.h fsl_lpuart.c fsl_lpuart.h fsl_port.h fsl_reset.c fsl_reset.h fsl_spc.c fsl_spc.h
  group lcdc
    lcdc/: fsl_st7796s.c fsl_st7796s.h
  group source
    source/: flexio_mculcd_int_transfer.c mcux_config.h mcuxsdk_version.h pin_mux.c pin_mux.h
  group startup/arm
    startup/arm/: startup_MCXA156.S
  group utilities/debug_console_lite
    utilities/debug_console_lite/: fsl_debug_console.c fsl_debug_console.h
  group utilities
    utilities/: fsl_assert.c fsl_assert.h fsl_memcpy.S
  group utilities/str
    utilities/str/: fsl_str.c fsl_str.h
  group video
    video/: fsl_dbi.c fsl_dbi.h fsl_video_common.c fsl_video_common.h
target flexio_mculcd release (6130001::V6.13.1::.\ARMCLANG)
  device: MCXA156VLL NXP
  pack: NXP.MCXA156_DFP.25.12.00
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU)  DSP
  output: flexio_mculcd.out
  AfterMake: as above
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, BOARD_LCD_S035=1, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MCXA156VLL, MCXA156_SERIES
  c misc: as above
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG,__CC_ARM,KEIL, MCUXPRESSO_SDK, CPU_MCXA156VLL, MCXA156_SERIES
  asm misc: -include ../mcux_config.h
  asm include: as above
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x2000
  memory RVCT5: ROM 0x13000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x1e000
  memory RVCT10: RAM 0x4000000 size 0x3000
  scatter file: MCXA156/mdk/MCXA156_flash.scf
  link misc: as above

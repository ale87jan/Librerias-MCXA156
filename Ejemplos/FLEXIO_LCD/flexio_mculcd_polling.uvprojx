# Keil uVision project flexio_mculcd_polling.uvprojx, settings and files
target Debug (6240000::V6.24::ARMCLANG)
  device: MCXA156VLL NXP
  pack: NXP.MCXA156_DFP.25.12.00
  cpu: IRAM(0x20000000,0x01e000) IRAM2(0x04000000,0x3000) IROM(0x03000000,0x2000) IROM2(0x00000000,0x100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: flexio_mculcd_polling.out
  AfterMake: fromelf.exe --output "$Lflexio_mculcd_polling.bin" --bincombined "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=6 v6LangP=4 wLevel=3
  c define: DEBUG, BOARD_LCD_S035=1, SDK_DEBUGCONSOLE=1, MCUX_META_BUILD, MCUXPRESSO_SDK, CPU_MCXA156VLL, MCXA156_SERIES
  c misc: -include mcux_config.h -include mcuxsdk_version.h -fno-common  -fdata-sections  -fno-builtin  -mthumb
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG,__CC_ARM,KEIL, MCUXPRESSO_SDK, CPU_MCXA156VLL, MCXA156_SERIES
  asm misc: -include mcux_config.h
  library: MicroLIB
  memory RVCT4: ROM 0x3000000 size 0x2000
  memory RVCT5: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1e000
  memory RVCT10: RAM 0x4000000 size 0x3000
  link misc: --remove --entry=Reset_Handler --info=sizes,totals,unused,veneers
  group source
    ./: flexio_mculcd_polling.c pin_mux.c pin_mux.h mcux_config.h mcuxsdk_version.h
  group board
    ./: board.c board.h clock_config.c clock_config.h hardware_init.c app.h
  group doc
    ./: readme.md example_board_readme.md examples_shared_readme.md
software components: CMSIS:CORE 6.2.0, Device:CMSIS:MCXA156_header 1.0.0, Device:CMSIS:MCXA156_system 1.0.0, Device:SDK Drivers:clock 2.0.0, Device:SDK Drivers:common 2.6.2, Device:SDK Drivers:dbi 1.0.0, Device:SDK Drivers:flexio 2.3.0, Device:SDK Drivers:flexio_mculcd 2.3.0, Device:SDK Drivers:gpio 2.8.3, Device:SDK Drivers:inputmux_connections 2.0.0, Device:SDK Drivers:lpuart 2.10.0, Device:SDK Drivers:lpuart_adapter 1.0.0, Device:SDK Drivers:mcx_spc 2.10.0, Device:SDK Drivers:port 2.5.1, Device:SDK Drivers:reset 2.4.0, Device:SDK Drivers:st7796s 1.0.0, Device:SDK Drivers:video-common 1.1.0, Device:SDK Utilities:MCXA156_linker 1.0.0, Device:SDK Utilities:assert_lite 1.0.0, Device:SDK Utilities:cmake_toolchain 1.0.0, Device:SDK Utilities:debug_console_lite 1.0.0, Device:SDK Utilities:str 1.0.0, Device:Startup 1.0.0

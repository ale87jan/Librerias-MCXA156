# Keil uVision project gpio_input_interrupt.uvprojx, settings and files
target gpio_input_interrupt debug (6240000::V6.24::ARMCLANG)
  device: MCXA156VLL NXP
  pack: NXP.MCXA156_DFP.25.12.00
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU)  DSP
  output: gpio_input_interrupt.out
  AfterMake: fromelf --bin -o "$L@L.bin" !L
  c flags: Optim=2 OneElfS=1 v6Lang=6 v6LangP=4 wLevel=3
  c misc: -fno-common  -fdata-sections  -fno-builtin -mthumb
  c include: ..;../../../..
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x2000
  memory RVCT5: ROM 0x13000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x1e000
  memory RVCT10: RAM 0x4000000 size 0x3000
  scatter file: .\MCXA156_ram.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314
  group source
    ../: gpio_input_interrupt.c
  group board
    ../: pin_mux.c pin_mux.h board.c board.h clock_config.c clock_config.h
  group doc
    ../: readme.md
target gpio_input_interrupt release (6240000::V6.24::ARMCLANG)
  device: MCXA156VLL NXP
  pack: NXP.MCXA156_DFP.25.12.00
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU)  DSP
  output: gpio_input_interrupt.out
  c flags: Optim=7 OneElfS=1 v6Lang=6 v6LangP=4 wLevel=3
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  c include: ..;../../../..
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG,__CC_ARM,KEIL
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x2000
  memory RVCT5: ROM 0x13000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x1e000
  memory RVCT10: RAM 0x4000000 size 0x3000
  scatter file: MCXA156_flash.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314
software components: CMSIS:CORE 5.9.0, Device:CMSIS:MCXA156_header 1.0.0, Device:CMSIS:MCXA156_system 1.0.0, Device:SDK Drivers:clock 2.0.0, Device:SDK Drivers:common 2.4.1, Device:SDK Drivers:gpio 2.7.3, Device:SDK Drivers:inputmux 2.0.7, Device:SDK Drivers:inputmux_connections 2.0.1, Device:SDK Drivers:lists 1.0.0, Device:SDK Drivers:lpuart 2.8.2, Device:SDK Drivers:lpuart_adapter 1.0.0, Device:SDK Drivers:mcx_spc 2.4.2, Device:SDK Drivers:port 2.5.0, Device:SDK Drivers:reset 2.0.0, Device:SDK Utilities:assert_lite 1.0.0, Device:SDK Utilities:debug_console_lite 1.0.0, Device:SDK Utilities:misc_utilities 1.1.1, Device:SDK Utilities:str 1.0.0, Device:Startup 1.1.0
